{attribute 'qualified_only'}
VAR_GLOBAL
	stKL6811InData		AT %I*	:	ST_KL6811InData;
	stKL6811OutData		AT %Q*	:	ST_KL6811OutData;
	stCommandBuffer				:	ST_DALIV2CommandBuffer;
END_VAR
